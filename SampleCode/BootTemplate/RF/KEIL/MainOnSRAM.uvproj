# Keil uVision project MainOnSRAM.uvproj, settings and files
target MainOnSRAM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: NUC505YO13Y Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x1FFFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: MainOnSRAM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: HAVE_CONFIG_H,ARM_MATH_CM4,__FPU_PRESENT = 1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC505Series\Include;..\..\..\..\Library\StdDriver\inc;..\hw;..\rf
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\main_on_sram.ld
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/ARM/: startup_NUC505Series.s
    ../../../../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c gpio.c i2s.c spi.c sys.c timer.c adc.c
  group User
    ../: main.c prc.c
  group flt
    ../flt/: interf_dec.c interf_enc.c rom_dec.c rom_enc.c sp_dec.c sp_enc.c
  group mdm
    ../mdm/: mdm.c
  group rf
    ../rf/: cmt_spi3.c cmt2300a.c cmt2300a_hal.c radio.c radio_if.c
  group hw
    ../hw/: com.c spp.c aud.c pdc.c gpc.c
